# Keil uVision project Project.uvprojx, settings and files
target B-L475E-IOT01_Ubidots (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: B-L475E-IOT01
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L475xx,USE_HAL_DRIVER,SENSOR,MBEDTLS_CONFIG_FILE=<ubidots_mbedtls_config.h>,ENABLE_IOT_INFO,ENABLE_IOT_ERROR,ENABLE_IOT_WARNING,USE_MBED_TLS,UBIDOTS,USE_WIFI
  c include: ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/B-L475E-IOT01;../Inc;../../../../../Common/Ubidots/Inc;../../../../../Common/Shared/Inc;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Drivers/BSP/Components/es_wifi;../../../../../../Drivers/BSP/Components/hts221;../../../../../../Drivers/BSP/Components/lis3mdl;../../../../../../Drivers/BSP/Components/lps22hb;../../../../../../Drivers/BSP/Components/lsm6dsl;../../../../../../Drivers/BSP/Components/vl53l0x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\B-L475E-IOT01.sct
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
  group Drivers/BSP/B-L475E-IOT01
    ../../../../../../Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01.c stm32l475e_iot01_accelero.c stm32l475e_iot01_gyro.c stm32l475e_iot01_hsensor.c stm32l475e_iot01_tsensor.c stm32l475e_iot01_psensor.c stm32l475e_iot01_magneto.c
  group Drivers/BSP/Components/LPS22HB
    ../../../../../../Drivers/BSP/Components/lps22hb/: lps22hb.c
  group Application/Wifi
    ../Src/: es_wifi_io.c wifi.c
  group Drivers/BSP/Components/HTS221
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_lptim.c stm32l4xx_hal_flash.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_sram.c stm32l4xx_hal_uart.c stm32l4xx_hal_rng.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_rcc.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_flash_ex.c stm32l4xx_ll_fmc.c stm32l4xx_hal.c stm32l4xx_hal_dac.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_usart.c stm32l4xx_hal_hash.c stm32l4xx_hal_nor.c stm32l4xx_hal_dma.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_tim.c stm32l4xx_hal_crc.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_wwdg.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_nand.c stm32l4xx_hal_i2c.c stm32l4xx_hal_spi.c
  group Drivers/BSP
    ../../../../../../Drivers/BSP/Components/es_wifi/: es_wifi.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Application/Ubidots
    ../../../../../Common/Ubidots/Src/: ubidots.c
  group Drivers/BSP/Components/LSM6DSL
    ../../../../../../Drivers/BSP/Components/lsm6dsl/: lsm6dsl.c
  group Drivers/BSP/Components/LIS3MDL
    ../../../../../../Drivers/BSP/Components/lis3mdl/: lis3mdl.c
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: vl53l0x_proximity.c stm32l4xx_it.c vl53l0x_platform.c stm32l4xx_hal_msp.c main.c
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: ecdh.c ecp.c x509.c cipher_wrap.c asn1write.c asn1parse.c padlock.c pem.c x509_csr.c ssl_ticket.c x509_create.c md4.c x509write_crt.c rsa.c certs.c sha256.c x509_crl.c base64.c md_wrap.c blowfish.c ctr_drbg.c md2.c cipher.c bignum.c pkcs12.c entropy.c version_features.c ecdsa.c md.c pkcs5.c ssl_cli.c aesni.c ssl_cache.c arc4.c timing.c dhm.c pkwrite.c version.c ssl_cookie.c des.c xtea.c debug.c entropy_poll.c camellia.c pkparse.c ssl_tls.c pk.c ecjpake.c havege.c pkcs11.c cmac.c sha1.c error.c pk_wrap.c gcm.c ecp_curves.c x509write_csr.c threading.c aes.c hmac_drbg.c oid.c x509_crt.c md5.c sha512.c platform.c ssl_ciphersuites.c ssl_srv.c ripemd160.c memory_buffer_alloc.c ccm.c
  group Drivers/BSP/Components/vl53l0x
    ../../../../../../Drivers/BSP/Components/vl53l0x/: vl53l0x_api_ranging.c vl53l0x_api_core.c vl53l0x_api_strings.c vl53l0x_api_calibration.c vl53l0x_api.c vl53l0x_platform_log.c
  group Application/Common
    ../../../../../Common/Shared/Src/: timedate.c entropy_hardware_poll.c net_tls_mbedtls.c mbedtls_net.c timingSystem.c rfu.c heap.c sensors_data.c net.c wifi_net.c STM32CubeRTCInterface.c net_tcp_wifi.c iot_flash_config.c http_lib.c cloud.c
    ../Src/: flash_l4.c
software components: CMSIS:CORE 4.3.0
