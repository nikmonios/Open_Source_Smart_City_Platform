# Keil uVision project Project.uvprojx, settings and files
target B-L475E-IOT01_Grovestreams (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: B-L475E-IOT01
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L475xx,USE_HAL_DRIVER,SENSOR,MBEDTLS_CONFIG_FILE=<grovestreams_mbedtls_config.h>,ENABLE_IOT_INFO,ENABLE_IOT_ERROR,ENABLE_IOT_WARNING,USE_MBED_TLS,GROVESTREAMS,USE_WIFI
  c include: ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/B-L475E-IOT01;../Inc;../../../../../Common/Grovestreams/Inc;../../../../../Common/Shared/Inc;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Drivers/BSP/Components/es_wifi;../../../../../../Drivers/BSP/Components/hts221;../../../../../../Drivers/BSP/Components/lis3mdl;../../../../../../Drivers/BSP/Components/lps22hb;../../../../../../Drivers/BSP/Components/lsm6dsl;../../../../../../Drivers/BSP/Components/vl53l0x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\B-L475E-IOT01.sct
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
  group Application/Wifi
    ../Src/: wifi.c es_wifi_io.c
  group Drivers/BSP/Components/LPS22HB
    ../../../../../../Drivers/BSP/Components/lps22hb/: lps22hb.c
  group Doc
    ../: readme.txt
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: cmac.c pkparse.c aesni.c debug.c threading.c ecp.c x509_csr.c cipher.c x509_crl.c certs.c rsa.c md2.c md4.c dhm.c sha256.c ccm.c aes.c x509write_crt.c pk_wrap.c md.c timing.c asn1parse.c sha512.c ripemd160.c pkcs11.c memory_buffer_alloc.c md5.c entropy.c pkwrite.c sha1.c pem.c md_wrap.c ssl_ciphersuites.c des.c blowfish.c ssl_ticket.c ssl_tls.c oid.c cipher_wrap.c pkcs5.c base64.c pkcs12.c bignum.c gcm.c ecjpake.c ecdsa.c platform.c camellia.c ctr_drbg.c ssl_srv.c xtea.c hmac_drbg.c asn1write.c havege.c ecp_curves.c ecdh.c x509write_csr.c ssl_cache.c padlock.c error.c version.c ssl_cookie.c version_features.c pk.c entropy_poll.c ssl_cli.c x509_create.c x509_crt.c arc4.c x509.c
  group Application/User
    ../Src/: stm32l4xx_hal_msp.c stm32l4xx_it.c vl53l0x_platform.c main.c vl53l0x_proximity.c
  group Drivers/BSP
    ../../../../../../Drivers/BSP/Components/es_wifi/: es_wifi.c
  group Drivers/BSP/Components/LSM6DSL
    ../../../../../../Drivers/BSP/Components/lsm6dsl/: lsm6dsl.c
  group Application/Grovestreams
    ../../../../../Common/Grovestreams/Src/: grovestreams.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_cortex.c stm32l4xx_hal_tim.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_rng.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_rcc.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_gpio.c stm32l4xx_hal_nor.c stm32l4xx_ll_fmc.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_uart.c stm32l4xx_hal.c stm32l4xx_hal_hash.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_sram.c stm32l4xx_hal_lptim.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_crc.c stm32l4xx_hal_wwdg.c stm32l4xx_hal_rtc.c stm32l4xx_hal_flash.c stm32l4xx_hal_nand.c stm32l4xx_hal_usart.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Application/Common
    ../../../../../Common/Shared/Src/: timedate.c heap.c sensors_data.c iot_flash_config.c net.c STM32CubeRTCInterface.c rfu.c http_lib.c entropy_hardware_poll.c net_tcp_wifi.c cloud.c wifi_net.c timingSystem.c net_tls_mbedtls.c mbedtls_net.c
    ../Src/: flash_l4.c
  group Drivers/BSP/B-L475E-IOT01
    ../../../../../../Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01_psensor.c stm32l475e_iot01_hsensor.c stm32l475e_iot01_accelero.c stm32l475e_iot01.c stm32l475e_iot01_tsensor.c stm32l475e_iot01_magneto.c stm32l475e_iot01_gyro.c
  group Drivers/BSP/Components/HTS221
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c
  group Drivers/BSP/Components/vl53l0x
    ../../../../../../Drivers/BSP/Components/vl53l0x/: vl53l0x_api.c vl53l0x_api_strings.c vl53l0x_api_ranging.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_platform_log.c
  group Drivers/BSP/Components/LIS3MDL
    ../../../../../../Drivers/BSP/Components/lis3mdl/: lis3mdl.c
software components: CMSIS:CORE 4.3.0
